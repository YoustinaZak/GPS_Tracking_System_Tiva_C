# Keil uVision project GPS_Tracking.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS_Tracking
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c
    ./LIB/: BIT_MATH.h
    ./MCAL/: BUTTON.c GPIO.c LED.c SYSTICK.c UART.c BUTTON.h GPIO.h LED.h SYSTICK.h UART.h EEPROM.h
    ./HAL/: LCD.c GPS.c LCD.h GPS.h
